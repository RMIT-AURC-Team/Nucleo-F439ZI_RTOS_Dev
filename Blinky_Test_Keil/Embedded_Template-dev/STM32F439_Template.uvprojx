# Keil uVision project STM32F439_Template.uvprojx, settings and files
target STM32F4 RAM (6160000::V6.16::ARMCLANG)
  device: STM32F439ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_RAM
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DAUGHTER_REV1 STM32F439
  c include: .\inc;.\inc\CMSIS;.\RTE\Device\STM32F439IIHx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./src/: stm32f4xx_it.c boardSupport.c main.c gpioControl.c
  group Headers
    ./inc/: main.h config.h boardSupport.h stm32f439xx.h ioMapping.h gpioControl.h stm32f4xx_it.h stm32f4xx.h
    ./RTE/Device/STM32F439IIHx/: system_stm32f4xx.h
target STM32F4 FLASH (6160000::V6.16::ARMCLANG)
  device: STM32F439IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: STM32F439_Template_Flash
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DAUGHTER_REV1 STM32F439
  c include: .\inc;.\inc\CMSIS;.\RTE\Device\STM32F439IIHx;.\inc\STM32F4xx_HAL_Driver\Inc;.\inc\STM32F4xx_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
